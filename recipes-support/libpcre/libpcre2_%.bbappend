EXTRA_OECONF = "\
    --enable-jit=auto \
     "

