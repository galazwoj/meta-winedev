# Disable LTTNG (contained in 'tools-profile' package group).
# lttng-modules interface clashes with Linux kernel 4.19+
LTTNGUST = ""
LTTNGTOOLS = ""
LTTNGMODULES = ""
