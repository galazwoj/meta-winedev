FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0017-binutils-drop-redundant-program_name-definition-fno-.patch \
    "
